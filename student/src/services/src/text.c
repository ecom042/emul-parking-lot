#include "services/text.h"

#include <errno.h>
#include <stdbool.h>
#include <stdio.h>
#include <string.h>

#define GLYPH_COLS 5
#define GLYPH_ROWS 7

/* One glyph: 5 columns, bit 0 of each column is the top row. */
struct glyph {
	char ch;
	uint8_t cols[GLYPH_COLS];
};

static const struct glyph font[] = {
	{' ', {0x00, 0x00, 0x00, 0x00, 0x00}}, {'.', {0x00, 0x60, 0x60, 0x00, 0x00}},
	{'0', {0x3E, 0x51, 0x49, 0x45, 0x3E}}, {'1', {0x00, 0x42, 0x7F, 0x40, 0x00}},
	{'2', {0x42, 0x61, 0x51, 0x49, 0x46}}, {'3', {0x21, 0x41, 0x45, 0x4B, 0x31}},
	{'4', {0x18, 0x14, 0x12, 0x7F, 0x10}}, {'5', {0x27, 0x45, 0x45, 0x45, 0x39}},
	{'6', {0x3C, 0x4A, 0x49, 0x49, 0x30}}, {'7', {0x01, 0x71, 0x09, 0x05, 0x03}},
	{'8', {0x36, 0x49, 0x49, 0x49, 0x36}}, {'9', {0x06, 0x49, 0x49, 0x29, 0x1E}},
	{'A', {0x7E, 0x11, 0x11, 0x11, 0x7E}}, {'B', {0x7F, 0x49, 0x49, 0x49, 0x36}},
	{'C', {0x3E, 0x41, 0x41, 0x41, 0x22}}, {'D', {0x7F, 0x41, 0x41, 0x22, 0x1C}},
	{'E', {0x7F, 0x49, 0x49, 0x49, 0x41}}, {'F', {0x7F, 0x09, 0x09, 0x09, 0x01}},
	{'G', {0x3E, 0x41, 0x49, 0x49, 0x7A}}, {'H', {0x7F, 0x08, 0x08, 0x08, 0x7F}},
	{'I', {0x00, 0x41, 0x7F, 0x41, 0x00}}, {'J', {0x20, 0x40, 0x41, 0x3F, 0x01}},
	{'K', {0x7F, 0x08, 0x14, 0x22, 0x41}}, {'L', {0x7F, 0x40, 0x40, 0x40, 0x40}},
	{'M', {0x7F, 0x02, 0x0C, 0x02, 0x7F}}, {'N', {0x7F, 0x04, 0x08, 0x10, 0x7F}},
	{'O', {0x3E, 0x41, 0x41, 0x41, 0x3E}}, {'P', {0x7F, 0x09, 0x09, 0x09, 0x06}},
	{'Q', {0x3E, 0x41, 0x51, 0x21, 0x5E}}, {'R', {0x7F, 0x09, 0x19, 0x29, 0x46}},
	{'S', {0x46, 0x49, 0x49, 0x49, 0x31}}, {'T', {0x01, 0x01, 0x7F, 0x01, 0x01}},
	{'U', {0x3F, 0x40, 0x40, 0x40, 0x3F}}, {'V', {0x1F, 0x20, 0x40, 0x20, 0x1F}},
	{'W', {0x3F, 0x40, 0x38, 0x40, 0x3F}}, {'X', {0x63, 0x14, 0x08, 0x14, 0x63}},
	{'Y', {0x07, 0x08, 0x70, 0x08, 0x07}}, {'Z', {0x61, 0x51, 0x49, 0x45, 0x43}},
};

static const struct glyph *find_glyph(char c)
{
	for (size_t i = 0; i < sizeof(font) / sizeof(font[0]); i++) {
		if (font[i].ch == c) {
			return &font[i];
		}
	}
	return NULL;
}

int text_format_brl(uint32_t cents, char *out, size_t size)
{
	int n = snprintf(out, size, "BRL %u.%02u", (unsigned int)(cents / 100),
			 (unsigned int)(cents % 100));

	return (n < 0 || (size_t)n >= size) ? -ENOSPC : n;
}

int text_width(const char *s, unsigned int scale)
{
	size_t len = strlen(s);

	if (scale == 0) {
		return -EINVAL;
	}
	for (size_t i = 0; i < len; i++) {
		if (find_glyph(s[i]) == NULL) {
			return -EINVAL;
		}
	}
	return (int)(len * TEXT_CELL_W * scale);
}

/* Is the pixel (x, y) of a glyph cell lit? The 6th column and 8th row are blank. */
static bool cell_pixel_on(const struct glyph *g, unsigned int x, unsigned int y)
{
	return x < GLYPH_COLS && y < GLYPH_ROWS && ((g->cols[x] >> y) & 1u);
}

int text_render_row(const char *s, unsigned int scale, unsigned int row,
		    uint16_t fg, uint16_t bg, uint8_t *out, size_t size)
{
	int width = text_width(s, scale);

	if (width < 0 || row >= TEXT_CELL_H * scale) {
		return -EINVAL;
	}
	if (size < (size_t)width * 2) {
		return -ENOSPC;
	}
	for (int x = 0; x < width; x++) {
		const struct glyph *g = find_glyph(s[x / (TEXT_CELL_W * scale)]);
		unsigned int cell_x = ((unsigned int)x / scale) % TEXT_CELL_W;
		uint16_t color = cell_pixel_on(g, cell_x, row / scale) ? fg : bg;

		out[2 * x] = (uint8_t)(color >> 8);
		out[2 * x + 1] = (uint8_t)(color & 0xFF);
	}
	return 0;
}
